Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-06-11T13:05:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jun 11 13:05:45 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{A18F0F6F-397C-4CFE-9217-C5D1E5EBE968}\ifc * Database version: 5507 * Database creation date: Mon Jun 11 13:05:43 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jun 11 13:05:44 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jun 11 13:05:44 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: Gaz naturel – Coffret S300, Gaz naturel – Coffret:Gaz naturel – Coffret S300:212419
In: Niveau 1
Type - PredefinedType: GASMETER; Material: GRDF-Creme
Type - Autre(Type) - Catégorie: Equipement de génie climatique; Nom de la famille: Gaz naturel – Coffret
Type - Contraintes(Type) - Hauteur: 525 mm; Largeur: 536 mm; Pose.sur.socle: yes; Profondeur: 215 mm
Type - Cotes(Type) - COFF.Debord.Encastrement: 25 mm; COFF.DeBord.encastrement.avant: 20 mm; COFF.Ep.Fond: 10 mm; COFF.Ep.Haut: 10 mm; COFF.Ep.Porte: 10 mm; COFF.Ep.Semelle: 150 mm; COFF.Epaisseur: 10 mm; COFF.Hauteur.Largeur.poteaux: 30 mm; COFF.Hauteur.socle.non.visible: 70 mm; COFF.Implan.poteaux: 40 mm; COFF.Pied.fond: 550 mm; COFF.Retrait.Porte: 5 mm
Type - Données d'identification(Type) - Nom du type: Gaz naturel – Coffret S300
Type - Matériaux et finitions(Type) - COFF.Beton: GRDF-Beton; COFF.Coffret: GRDF-Creme
Pset_DistributionFlowElementCommon - Reference: Gaz naturel – Coffret S300
Autre - Catégorie: Equipement de génie climatique; COFF.Pas socle ouvert: yes; CONN.AR.Deccalage.gauche: 50 mm; CONN.AR.Deccalage.Haut: 100 mm; CONN.DEP.Deccalage.Droite: 50 mm; CONN.DEP.Deccalage.Haut: 100 mm; Famille: Gaz naturel – Coffret: Gaz naturel – Coffret S300; Famille et type: Gaz naturel – Coffret: Gaz naturel – Coffret S300; ID du type: Gaz naturel – Coffret: Gaz naturel – Coffret S300; Porte.fermee: yes; Pose.encastree: no; Type: Gaz naturel – Coffret: Gaz naturel – Coffret S300
Contraintes - Décalage: 0 mm; En savoir plus: https://cegibat.grdf.fr/simulateur/alimentation-gaz-logements-collectifs-cicm; Hôte: Niveau : Niveau 1; Implantation du coffret: encastrée; Lien vers les objets génériques au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments/objets-bim-gaz-naturel; Niveau: Niveau: Niveau 1; Porte.ouverte: no; Présence compteur: no; Présence détendeur/régulateur: no; Présence organe de coupure: no
Cotes - COFF.Hauteur.Implant.ou.hauteur.socle: 600 mm; COFF.Hauteur.socle.visible: 600 mm; Hauteur totale: 1100 mm; Surface: 2.04171 m2; Volume: 0.087153 m3
Données - ARM.PART.Hauteur: 525 mm; ARM.PART.Longueur: 536 mm; ARM.PART.Profondeur: 215 mm
Données d'identification - Identifiant: 4
Génie climatique - Classification du système: Non défini
Génie climatique - Ecoulement - COFF.Débit MAX (L/s): 0 m3/s; COFF.Pression Amont (Pa): 0 Pa; COFF.Pression Amont MAX (Pa): 0 Pa; COFF.Pression Aval (Pa): 0 Pa; COFF.Pression Aval MAX (Pa): 0 Pa; CONN.DN.Amont: 60 mm; CONN.DN.Dep: 60 mm
Phase de construction - Phase de création: Nouvelle construction
